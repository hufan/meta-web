IMAGE_INSTALL += "imx-kobs \
    mtd-utils \
    mtd-utils-ubifs \
    rpm \
    udev-extraconf \
    udev-rules-imx \

