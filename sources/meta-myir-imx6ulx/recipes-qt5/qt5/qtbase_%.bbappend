# Copyright (C) 2013 Eric Bénard - Eukréa Electromatique

PACKAGECONFIG_append = " accessibility examples linuxfb"
PACKAGECONFIG_append_pn-qtbase = " sql-sqlite"
