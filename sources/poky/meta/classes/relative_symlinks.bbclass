do_install[postfuncs] += "install_relative_symlinks"

python install_relative_symlinks () {
	print "hunffffffffff"

}
